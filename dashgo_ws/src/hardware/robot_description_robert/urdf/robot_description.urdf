Commit message: Changed frames to corresponding namespace

File: dashgo_ws/src/hardware/robot_description_robert/urdf/robot_description.urdf (robot description, URDF)
Before this commit: robot robot_description, 3 links, 2 joints
Links:
- removed link laser
Joints:
- removed joint lidar_joint
